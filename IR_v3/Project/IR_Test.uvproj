# Keil uVision project IR_Test.uvproj, settings and files
target IR_v3 (MCS-51)
  device: SH77P1651 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0-0xFF) CLOCK(4000000)
  output: IR_v2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\App;..\Inc;..\Src;..\Core
  group App
    ../App/: App.c main.c App.h user.h
  group Src
    ../Src/: timer.c LCD.c INT4.c
  group Inc
    ../Inc/: timer.h LCD.h Mytypedef.h INT4.h
  group Core
    ../Core/: Coder.h Coder.LIB
  group Document
    ../: readme.txt
